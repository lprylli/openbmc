FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-interface-for-AC-restore-always-on-policy.patch \
           "
