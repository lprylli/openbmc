FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Implement-the-AC-restore-random-and-fixed-delay.patch \
           "
