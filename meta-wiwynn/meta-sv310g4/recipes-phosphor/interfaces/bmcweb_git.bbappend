FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-HTTP-download-method-for-host-console-logs.patch"

