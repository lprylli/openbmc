FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-Disable-to-release-IP-from-DHCP.patch \ 
           "
