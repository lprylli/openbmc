FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Set-fixed-static-IP-address-for-usb0-interface.patch"

