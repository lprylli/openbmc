REPENDS_${PN}-ikvm_remove += " \
    obmc-ikvm \
    "
