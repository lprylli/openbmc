FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

OBMC_CONSOLE_HOST_TTY = "ttyS0"
