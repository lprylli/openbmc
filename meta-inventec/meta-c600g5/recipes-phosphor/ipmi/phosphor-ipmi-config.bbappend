FILESEXTRAPATHS_prepend_c600g5 := "${THISDIR}/${PN}:"
