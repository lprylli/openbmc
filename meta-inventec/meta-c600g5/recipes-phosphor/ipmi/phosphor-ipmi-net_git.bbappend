FILESEXTRAPATHS_prepend_c600g5 := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Support-HMAC-SHA1-to-Authentication-and-Integ.patch \
           "
