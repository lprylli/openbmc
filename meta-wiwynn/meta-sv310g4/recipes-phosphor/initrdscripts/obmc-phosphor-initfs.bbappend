FILESEXTRAPATHS_prepend_sv310g4 := "${THISDIR}/${PN}:"
